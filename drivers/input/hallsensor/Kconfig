## drivers/input/hallsensor/Kconfig
```kconfig
config HALL_SWITCH
	tristate "Hall Switch driver"
	default n
	---help---
	  Say Y here for supporting Hall Switch.
```
